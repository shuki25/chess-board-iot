# Repository shuki25/chess-board-iot

## KiCad design chess-board-iot.kicad_pcb

Board: 2 copper layers, 441 parts (0 on the bottom side), 228 nets, no tracks yet.

Parts:
C101, C105, C106, C201, C202, C203, C204, C205, C206, C207, C208, C209, C210, C211, C212, C213, C214, C215, C216, C217, C218, C219, C220, C221, C222, C223, C224, C225, C226, C227, C228, C229, C230, C231, C232, C233, C234, C235, C236, C237, C238, C239, C240, C241, C242, C243, C244, C245, C246, C247, C248, C249, C250, C251, C252, C253, C254, C255, C256, C257, C258, C259, C260, C261, C262, C263, C264, C401, C402, C403, C404, C405, C406, C407, C408, C409, C410, C411, C412, C413, C414, C415, C416, C417, C418, C419, C420, C421, C422, C423, C424, C425, C426, C427, C428, C429, C430, C431, C432, C433, C434, C435, C436, C437, C438, C439, C440, C441, C442, C443, C444, C445, C446, C447, C448, C449, C450, C451, C452, C453, C454, C455, C456, C457, C458, C459, C460, C461, C462, C463, C464: 100nF; C_0603_1608Metric
C102: 22uF; C_0603_1608Metric
C103: 4.7uF; C_0603_1608Metric
C104: 4.7nF; C_0603_1608Metric
D201, D202, D203, D204, D205, D206, D207, D208, D209, D210, D211, D212, D213, D214, D215, D216, D217, D218, D219, D220, D221, D222, D223, D224, D225, D226, D227, D228, D229, D230, D231, D232, D233, D234, D235, D236, D237, D238, D239, D240, D241, D242, D243, D244, D245, D246, D247, D248, D249, D250, D251, D252, D253, D254, D255, D256, D257, D258, D259, D260, D261, D262, D263, D264: WS2813C; LED_WS2812_PLCC6_5.0x5.0mm_P1.6mm
H101, H102, H103, H104, H105, H106, H107, H108, H109: MountingHole; MountingHole_2.7mm_M2.5_ISO7380
J101: USB_C_Receptacle_USB2.0; GCT_USB4125-GF-A-0190_REVA2
J102: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
OLED101, OLED102: OLED_I2C; OLED_128x32_I2C_4pins
OLED103: OLED_I2C; OLED_128x64_I2C_4pins_0.96in
Q101, Q102: S8050; SOT-23
R101, R109, R110: 10K; R_0603_1608Metric
R102, R103: 5K1; R_0805_2012Metric
R104: 1M; R_0603_1608Metric
R105, R106, R107, R108, R111, R112, R301, R302, R303, R304: 4K7; R_0603_1608Metric
R201, R202, R203, R204, R205, R206, R207, R208, R209, R210, R211, R212, R214, R215, R216, R217, R218, R219, R220, R221, R222, R223, R224, R225, R226, R227, R228, R229, R230, R231, R232, R233, R234, R235, R236, R237, R238, R239, R240, R241, R242, R243, R244, R245, R246, R247, R248, R249, R250, R251, R252, R253, R254, R255, R256, R257, R258, R259, R260, R261, R262, R263, R264, R265: 200; R_0603_1608Metric
R213: 100; R_0603_1608Metric
R401, R402, R403, R404, R405, R406, R407, R408, R409, R410, R411, R412, R413, R414, R415, R416, R417, R418, R419, R420, R421, R422, R423, R424, R425, R426, R427, R428, R429, R430, R431, R432, R433, R434, R435, R436, R437, R438, R439, R440, R441, R442, R443, R444, R445, R446, R447, R448, R449, R450, R451, R452, R453, R454, R455, R456, R457, R458, R459, R460, R461, R462, R463, R464: 2K7; R_0603_1608Metric
SW101, SW102, SW103, SW104, SW105, SW106, SW107, SW108, SW109: SW_SPST; Button_SW_12mm_1.8mm_hole
U101: XC6220B331MR-G; SOT-23-5
U102: ESP32-WROOM-32E; ESP32-WROOM-32
U103: SRV05-4; SOT-23-6
U104: PCA9548APW; TSSOP-24_4.4x7.8mm_P0.65mm
U105: CP2102-GMR; QFN-28-1EP_5x5mm_P0.5mm_EP3.35x3.35mm
U301, U302, U303, U304: PCA9535C; TSSOP-24_4.4x7.8mm_P0.65mm
U401, U402, U403, U404, U405, U406, U407, U408, U409, U410, U411, U412, U413, U414, U415, U416, U417, U418, U419, U420, U421, U422, U423, U424, U425, U426, U427, U428, U429, U430, U431, U432, U433, U434, U435, U436, U437, U438, U439, U440, U441, U442, U443, U444, U445, U446, U447, U448, U449, U450, U451, U452, U453, U454, U455, U456, U457, U458, U459, U460, U461, U462, U463, U464: UHE4913; SOT-23

Connections:
3V3: C103.1, C106.1, C401.1, C402.1, C403.1, C404.1, C405.1, C406.1, C407.1, C408.1, C409.1, C410.1, C411.1, C412.1, C413.1, C414.1, C415.1, C416.1, C417.1, C418.1, C419.1, C420.1, C421.1, C422.1, C423.1, C424.1, C425.1, C426.1, C427.1, C428.1, C429.1, C430.1, C431.1, C432.1, C433.1, C434.1, C435.1, C436.1, C437.1, C438.1, C439.1, C440.1, C441.1, C442.1, C443.1, C444.1, C445.1, C446.1, C447.1, C448.1, C449.1, C450.1, C451.1, C452.1, C453.1, C454.1, C455.1, C456.1, C457.1, C458.1, C459.1, C460.1, C461.1, C462.1, C463.1, C464.1, OLED101.2 (VCC), OLED102.2 (VCC), OLED103.2 (VCC), R101.1, R105.1, R106.1, R107.2, R108.2, R111.1, R112.2, R301.1, R302.1, R303.1, R304.1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
5V: C102.1, D201.2 (VDD), D202.2 (VDD), D203.2 (VDD), D204.2 (VDD), D205.2 (VDD), D206.2 (VDD), D207.2 (VDD), D208.2 (VDD), D209.2 (VDD), D210.2 (VDD), D211.2 (VDD), D212.2 (VDD), D213.2 (VDD), D214.2 (VDD), D215.2 (VDD), D216.2 (VDD), D217.2 (VDD), D218.2 (VDD), D219.2 (VDD), D220.2 (VDD), D221.2 (VDD), D222.2 (VDD), D223.2 (VDD), D224.2 (VDD), D225.2 (VDD), D226.2 (VDD), D227.2 (VDD), D228.2 (VDD), D229.2 (VDD), D230.2 (VDD), D231.2 (VDD), D232.2 (VDD), D233.2 (VDD), D234.2 (VDD), D235.2 (VDD), D236.2 (VDD), D237.2 (VDD), D238.2 (VDD), D239.2 (VDD), D240.2 (VDD), D241.2 (VDD), D242.2 (VDD), D243.2 (VDD), D244.2 (VDD), D245.2 (VDD), D246.2 (VDD), D247.2 (VDD), D248.2 (VDD), D249.2 (VDD), D250.2 (VDD), D251.2 (VDD), D252.2 (VDD), D253.2 (VDD), D254.2 (VDD), D255.2 (VDD), D256.2 (VDD), D257.2 (VDD), D258.2 (VDD), D259.2 (VDD), D260.2 (VDD), D261.2 (VDD), D262.2 (VDD), D263.2 (VDD), D264.2 (VDD), J102.1, R201.1, R202.1, R203.1, R204.1, R205.1, R206.1, R207.1, R208.1, R209.1, R210.1, R211.1, R212.1, R214.1, R215.1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
/DTR: Q102.2 (E), R109.2, U105.28 (~DTR)
/D_N: U103.3 (IO2), U105.5 (D-)
/D_P: U103.1 (IO1), U105.4 (D+)
/EN: C101.1, Q101.3 (C), R101.2, U102.3 (EN)
/I2C_A0: U102.10 (IO25), U104.1 (A0)
/I2C_A1: U102.11 (IO26), U104.2 (A1)
/I2C_A2: U102.12 (IO27), U104.21 (A2)
/IO0: Q102.3 (C), U102.25 (IO0)
/RTS: Q101.2 (E), R110.2, U105.24 (~RTS)
/RXD: U102.35 (TXD0/IO1), U105.25 (RXD)
/SCL_DB: OLED102.4 (SDA), R106.2, U104.9 (SC2)
/SCL_DM: OLED103.4 (SDA), R111.2, U104.7 (SC1), U104.11 (SC3)
/SCL_DW: OLED101.4 (SDA), R105.2
/SDA_DB: OLED102.3 (SCL), R108.1, U104.8 (SD2)
/SDA_DM: OLED103.3 (SCL), R112.1, U104.6 (SD1), U104.10 (SD3)
/SDA_DW: OLED101.3 (SCL), R107.1
/TXD: U102.34 (RXD0/IO3), U105.26 (TXD)
/~I2C_RESET: U102.37 (IO23), U104.3 (~RESET)
/~I2C_SCL: U102.36 (IO22), U104.22 (SCL)
/~I2C_SDA: U102.33 (IO21), U104.23 (SDA)
GND: C101.2, C102.2, C103.2, C104.2, C105.2, C106.2, C201.2, C202.2, C203.2, C204.2, C205.2, C206.2, C207.2, C208.2, C209.2, C210.2, C211.2, C212.2, C213.2, C214.2, C215.2, C216.2, C217.2, C218.2, C219.2, C220.2, C221.2, C222.2, C223.2, C224.2, C225.2, C226.2, C227.2, C228.2, C229.2, C230.2, C231.2, C232.2, C233.2, C234.2, C235.2, C236.2, C237.2, C238.2, C239.2, C240.2, C241.2, C242.2, C243.2, C244.2, C245.2, C246.2, C247.2, C248.2, C249.2, C250.2, C251.2, C252.2, C253.2, C254.2, C255.2, C256.2, C257.2, C258.2, C259.2, C260.2, C261.2, C262.2, C263.2, C264.2, C401.2, C402.2, C403.2, C404.2, C405.2, C406.2, C407.2, C408.2, C409.2, C410.2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
LED_IC: R213.1, U102.30 (IO18)
unnamed: C104.1, J101.S1 (SHIELD), R104.2
unnamed: C201.1, D201.1 (VCC), R201.2
unnamed: C202.1, D202.1 (VCC), R202.2
unnamed: C203.1, D203.1 (VCC), R203.2
unnamed: C204.1, D204.1 (VCC), R204.2
unnamed: C205.1, D205.1 (VCC), R205.2
unnamed: C206.1, D206.1 (VCC), R206.2
unnamed: C207.1, D207.1 (VCC), R207.2
unnamed: C208.1, D208.1 (VCC), R208.2
unnamed: C209.1, D209.1 (VCC), R209.2
unnamed: C210.1, D210.1 (VCC), R210.2
unnamed: C211.1, D211.1 (VCC), R211.2
unnamed: C212.1, D212.1 (VCC), R212.2
unnamed: C213.1, D213.1 (VCC), R214.2
unnamed: C214.1, D214.1 (VCC), R215.2
unnamed: C215.1, D215.1 (VCC), R216.2
unnamed: C216.1, D216.1 (VCC), R217.2
unnamed: C217.1, D217.1 (VCC), R218.2
unnamed: C218.1, D218.1 (VCC), R219.2
unnamed: C219.1, D219.1 (VCC), R220.2
unnamed: C220.1, D220.1 (VCC), R221.2
unnamed: C221.1, D221.1 (VCC), R222.2
unnamed: C222.1, D222.1 (VCC), R223.2
unnamed: C223.1, D223.1 (VCC), R224.2
unnamed: C224.1, D224.1 (VCC), R225.2
unnamed: C225.1, D225.1 (VCC), R226.2
unnamed: C226.1, D226.1 (VCC), R227.2
unnamed: C227.1, D227.1 (VCC), R228.2
unnamed: C228.1, D228.1 (VCC), R229.2
unnamed: C229.1, D229.1 (VCC), R230.2
unnamed: C230.1, D230.1 (VCC), R231.2
unnamed: C231.1, D231.1 (VCC), R232.2
unnamed: C232.1, D232.1 (VCC), R233.2
unnamed: C233.1, D233.1 (VCC), R234.2
unnamed: C234.1, D234.1 (VCC), R235.2
unnamed: C235.1, D235.1 (VCC), R236.2
unnamed: C236.1, D236.1 (VCC), R237.2
unnamed: C237.1, D237.1 (VCC), R238.2
unnamed: C238.1, D238.1 (VCC), R239.2
unnamed: C239.1, D239.1 (VCC), R240.2
unnamed: C240.1, D240.1 (VCC), R241.2
unnamed: C241.1, D241.1 (VCC), R242.2
unnamed: C242.1, D242.1 (VCC), R243.2
unnamed: C243.1, D243.1 (VCC), R244.2
unnamed: C244.1, D244.1 (VCC), R245.2
unnamed: C245.1, D245.1 (VCC), R246.2
unnamed: C246.1, D246.1 (VCC), R247.2
unnamed: C247.1, D247.1 (VCC), R248.2
unnamed: C248.1, D248.1 (VCC), R249.2
unnamed: C249.1, D249.1 (VCC), R250.2
unnamed: C250.1, D250.1 (VCC), R251.2
unnamed: C251.1, D251.1 (VCC), R252.2
unnamed: C252.1, D252.1 (VCC), R253.2
unnamed: C253.1, D253.1 (VCC), R254.2
unnamed: C254.1, D254.1 (VCC), R255.2
unnamed: C255.1, D255.1 (VCC), R256.2
unnamed: C256.1, D256.1 (VCC), R257.2
unnamed: C257.1, D257.1 (VCC), R258.2
unnamed: C258.1, D258.1 (VCC), R259.2
unnamed: C259.1, D259.1 (VCC), R260.2
unnamed: C260.1, D260.1 (VCC), R261.2
unnamed: C261.1, D261.1 (VCC), R262.2
unnamed: C262.1, D262.1 (VCC), R263.2
unnamed: C263.1, D263.1 (VCC), R264.2
unnamed: C264.1, D264.1 (VCC), R265.2
unnamed: D201.3 (DOUT), D202.4 (DIN), D203.6 (BIN)
unnamed: D201.4 (DIN), D202.6 (BIN), R213.2
unnamed: D202.3 (DOUT), D203.4 (DIN), D204.6 (BIN)
unnamed: D203.3 (DOUT), D204.4 (DIN), D205.6 (BIN)
unnamed: D204.3 (DOUT), D205.4 (DIN), D206.6 (BIN)
unnamed: D205.3 (DOUT), D206.4 (DIN), D207.6 (BIN)
unnamed: D206.3 (DOUT), D207.4 (DIN), D208.6 (BIN)
unnamed: D207.3 (DOUT), D208.4 (DIN), D209.6 (BIN)
unnamed: D208.3 (DOUT), D209.4 (DIN), D210.6 (BIN)
unnamed: D209.3 (DOUT), D210.4 (DIN), D211.6 (BIN)
unnamed: D210.3 (DOUT), D211.4 (DIN), D212.6 (BIN)
unnamed: D211.3 (DOUT), D212.4 (DIN), D213.6 (BIN)
unnamed: D212.3 (DOUT), D213.4 (DIN), D214.6 (BIN)
unnamed: D213.3 (DOUT), D214.4 (DIN), D215.6 (BIN)
unnamed: D214.3 (DOUT), D215.4 (DIN), D216.6 (BIN)
unnamed: D215.3 (DOUT), D216.4 (DIN), D217.6 (BIN)
unnamed: D216.3 (DOUT), D217.4 (DIN), D218.6 (BIN)
unnamed: D217.3 (DOUT), D218.4 (DIN), D219.6 (BIN)
unnamed: D218.3 (DOUT), D219.4 (DIN), D220.6 (BIN)
unnamed: D219.3 (DOUT), D220.4 (DIN), D221.6 (BIN)
unnamed: D220.3 (DOUT), D221.4 (DIN), D222.6 (BIN)
unnamed: D221.3 (DOUT), D222.4 (DIN), D223.6 (BIN)
unnamed: D222.3 (DOUT), D223.4 (DIN), D224.6 (BIN)
unnamed: D223.3 (DOUT), D224.4 (DIN), D225.6 (BIN)
unnamed: D224.3 (DOUT), D225.4 (DIN), D226.6 (BIN)
unnamed: D225.3 (DOUT), D226.4 (DIN), D227.6 (BIN)
unnamed: D226.3 (DOUT), D227.4 (DIN), D228.6 (BIN)
unnamed: D227.3 (DOUT), D228.4 (DIN), D229.6 (BIN)
unnamed: D228.3 (DOUT), D229.4 (DIN), D230.6 (BIN)
unnamed: D229.3 (DOUT), D230.4 (DIN), D231.6 (BIN)
unnamed: D230.3 (DOUT), D231.4 (DIN), D232.6 (BIN)
unnamed: D231.3 (DOUT), D232.4 (DIN), D233.6 (BIN)
unnamed: D232.3 (DOUT), D233.4 (DIN), D234.6 (BIN)
unnamed: D233.3 (DOUT), D234.4 (DIN), D235.6 (BIN)
unnamed: D234.3 (DOUT), D235.4 (DIN), D236.6 (BIN)
unnamed: D235.3 (DOUT), D236.4 (DIN), D237.6 (BIN)
unnamed: D236.3 (DOUT), D237.4 (DIN), D238.6 (BIN)
unnamed: D237.3 (DOUT), D238.4 (DIN), D239.6 (BIN)
unnamed: D238.3 (DOUT), D239.4 (DIN), D240.6 (BIN)
unnamed: D239.3 (DOUT), D240.4 (DIN), D241.6 (BIN)
unnamed: D240.3 (DOUT), D241.4 (DIN), D242.6 (BIN)
unnamed: D241.3 (DOUT), D242.4 (DIN), D243.6 (BIN)
unnamed: D242.3 (DOUT), D243.4 (DIN), D244.6 (BIN)
unnamed: D243.3 (DOUT), D244.4 (DIN), D245.6 (BIN)
unnamed: D244.3 (DOUT), D245.4 (DIN), D246.6 (BIN)
unnamed: D245.3 (DOUT), D246.4 (DIN), D247.6 (BIN)
unnamed: D246.3 (DOUT), D247.4 (DIN), D248.6 (BIN)
unnamed: D247.3 (DOUT), D248.4 (DIN), D249.6 (BIN)
unnamed: D248.3 (DOUT), D249.4 (DIN), D250.6 (BIN)
unnamed: D249.3 (DOUT), D250.4 (DIN), D251.6 (BIN)
unnamed: D250.3 (DOUT), D251.4 (DIN), D252.6 (BIN)
unnamed: D251.3 (DOUT), D252.4 (DIN), D253.6 (BIN)
unnamed: D252.3 (DOUT), D253.4 (DIN), D254.6 (BIN)
unnamed: D253.3 (DOUT), D254.4 (DIN), D255.6 (BIN)
unnamed: D254.3 (DOUT), D255.4 (DIN), D256.6 (BIN)
unnamed: D255.3 (DOUT), D256.4 (DIN), D257.6 (BIN)
unnamed: D256.3 (DOUT), D257.4 (DIN), D258.6 (BIN)
unnamed: D257.3 (DOUT), D258.4 (DIN), D259.6 (BIN)
unnamed: D258.3 (DOUT), D259.4 (DIN), D260.6 (BIN)
unnamed: D259.3 (DOUT), D260.4 (DIN), D261.6 (BIN)
unnamed: D260.3 (DOUT), D261.4 (DIN), D262.6 (BIN)
unnamed: D261.3 (DOUT), D262.4 (DIN), D263.6 (BIN)
unnamed: D262.3 (DOUT), D263.4 (DIN), D264.6 (BIN)
unnamed: D263.3 (DOUT), D264.4 (DIN)
unnamed: J101.A5 (CC1), R102.2
unnamed: J101.B5 (CC2), R103.2
unnamed: Q101.1 (B), R109.1
unnamed: Q102.1 (B), R110.1
unnamed: R301.2, U302.21 (A0)
unnamed: R302.2, U303.2 (A1)
unnamed: R303.2, U304.2 (A1)
unnamed: R455.2, U455.2 (VOUT)
Tile_01: R401.2, U301.4 (P00), U401.2 (VOUT)
Tile_02: R402.2, U301.5 (P01), U402.2 (VOUT)
Tile_03: R403.2, U301.6 (P02), U403.2 (VOUT)
Tile_04: R404.2, U301.7 (P03), U404.2 (VOUT)
Tile_05: R405.2, U301.8 (P04), U405.2 (VOUT)
Tile_06: R406.2, U301.9 (P05), U406.2 (VOUT)
Tile_07: R407.2, U301.10 (P06), U407.2 (VOUT)
Tile_08: R408.2, U301.11 (P07), U408.2 (VOUT)
Tile_09: R409.2, U301.13 (P10), U409.2 (VOUT)
Tile_10: R410.2, U301.14 (P11), U410.2 (VOUT)
Tile_11: R411.2, U301.15 (P12), U411.2 (VOUT)
Tile_12: R412.2, U301.16 (P13), U412.2 (VOUT)
Tile_13: R413.2, U301.17 (P14), U413.2 (VOUT)
Tile_14: R414.2, U301.18 (P15), U414.2 (VOUT)
Tile_15: R415.2, U301.19 (P16), U415.2 (VOUT)
Tile_16: R416.2, U301.20 (P17), U416.2 (VOUT)
Tile_17: R417.2, U302.4 (P00), U417.2 (VOUT)
Tile_18: R418.2, U302.5 (P01), U418.2 (VOUT)
Tile_19: R419.2, U302.6 (P02), U419.2 (VOUT)
Tile_20: R420.2, U302.7 (P03), U420.2 (VOUT)
Tile_21: R421.2, U302.8 (P04), U421.2 (VOUT)
Tile_22: R422.2, U302.9 (P05), U422.2 (VOUT)
Tile_23: R423.2, U302.10 (P06), U423.2 (VOUT)
Tile_24: R424.2, U302.11 (P07), U424.2 (VOUT)
Tile_25: R425.2, U302.13 (P10), U425.2 (VOUT)
Tile_26: R426.2, U302.14 (P11), U426.2 (VOUT)
Tile_27: R427.2, U302.15 (P12), U427.2 (VOUT)
Tile_28: R428.2, U302.16 (P13), U428.2 (VOUT)
Tile_29: R429.2, U302.17 (P14), U429.2 (VOUT)
Tile_30: R430.2, U302.18 (P15), U430.2 (VOUT)
Tile_31: R431.2, U302.19 (P16), U431.2 (VOUT)
Tile_32: R432.2, U302.20 (P17), U432.2 (VOUT)
Tile_33: R433.2, U303.4 (P00), U433.2 (VOUT)
Tile_34: R434.2, U303.5 (P01), U434.2 (VOUT)
Tile_35: R435.2, U303.6 (P02), U435.2 (VOUT)
Tile_36: R436.2, U303.7 (P03), U436.2 (VOUT)
Tile_37: R437.2, U303.8 (P04), U437.2 (VOUT)
Tile_38: R438.2, U303.9 (P05), U438.2 (VOUT)
Tile_39: R439.2, U303.10 (P06), U439.2 (VOUT)
Tile_40: R440.2, U303.11 (P07), U440.2 (VOUT)
Tile_41: R441.2, U303.13 (P10), U441.2 (VOUT)
Tile_42: R442.2, U303.14 (P11), U442.2 (VOUT)
Tile_43: R443.2, U303.15 (P12), U443.2 (VOUT)
Tile_44: R444.2, U303.16 (P13), U444.2 (VOUT)
Tile_45: R445.2, U303.17 (P14), U445.2 (VOUT)
Tile_46: R446.2, U303.18 (P15), U446.2 (VOUT)
Tile_47: R447.2, U303.19 (P16), U447.2 (VOUT)
Tile_48: R448.2, U303.20 (P17), U448.2 (VOUT)
Tile_49: R449.2, U304.4 (P00), U449.2 (VOUT)
Tile_50: R450.2, U304.5 (P01), U450.2 (VOUT)
Tile_51: R451.2, U304.6 (P02), U451.2 (VOUT)
Tile_52: R452.2, U304.7 (P03), U452.2 (VOUT)
Tile_53: R453.2, U304.8 (P04), U453.2 (VOUT)
Tile_54: R454.2, U304.9 (P05), U454.2 (VOUT)
Tile_56: R456.2, U304.11 (P07), U456.2 (VOUT)
Tile_57: R457.2, U304.13 (P10), U457.2 (VOUT)
Tile_58: R458.2, U304.14 (P11), U458.2 (VOUT)
Tile_59: R459.2, U304.15 (P12), U459.2 (VOUT)
Tile_60: R460.2, U304.16 (P13), U460.2 (VOUT)
Tile_61: R461.2, U304.17 (P14), U461.2 (VOUT)
Tile_62: R462.2, U304.18 (P15), U462.2 (VOUT)
Tile_63: R463.2, U304.19 (P16), U463.2 (VOUT)
Tile_64: R464.2, U304.20 (P17), U464.2 (VOUT)
VBUS: C105.1, J101.A9 (VBUS), J101.B9 (VBUS), J102.2, U103.5 (VP), U105.7 (VREGIN), U105.8 (VBUS)
~IO_INT: U102.26 (IO4), U301.1 (~INT), U302.1 (~INT), U303.1 (~INT), U304.1 (~INT)
~SCL: U104.5 (SC0), U301.22 (SCL), U302.22 (SCL), U303.22 (SCL), U304.22 (SCL)
~SDA: U104.4 (SD0), U301.23 (SDA), U302.23 (SDA), U303.23 (SDA), U304.23 (SDA)

## Commit log

2022-09-18 add hall sensors schematic
2022-09-18 add reed switches schematic
2022-09-18 add addressable RGB LEDs
2022-09-18 add I/O expander schematics
2022-09-18 update main schematic with hierarchical sheets
2022-09-18 initial PCB commit
2022-09-18 add schematic PDFs
2022-09-19 update PCB layout
2022-09-19 update schematic with corrections
2022-09-19 refactor IO expander pin assignment
2022-09-19 update PCB traces
2022-09-20 update more layout
2022-09-21 update schematic to include more components
    Added SD card
    Added IO expander for tactile buttons
2022-09-21 add more components to PCB
2022-09-21 update schematic PDFs
2022-09-21 change wording from TTL to UART
2022-09-25 update schematics
2022-09-26 add level translator and fix OLED pin assignment
2022-09-26 fix DRC errors
2022-09-26 add kicad and oshw logo
2022-09-30 repurpose design with Nextion display
2022-10-01 add bypass caps
2022-10-01 update layout with bypass caps
2022-10-01 update pdfs and screenshots
2022-10-01 update LCSC info
2022-10-05 refactor power rail
2022-10-05 add pre-defined track width
2022-10-05 update trace layout for SD card / power rail
2022-10-07 add production files
2022-10-08 update pin assignments and footprint for hall sensors
2022-10-08 fix sd card layout
2022-10-09 fix USB-C footprint and traces
2022-10-09 add JLCPCB production files
2022-10-09 remove notes
2022-10-09 update part numbers
2022-10-09 update JLCPCB production files
2022-10-09 update pcb file
2022-10-10 update Nextion 3D models
2022-10-18 add buck converter, switch ESD component
2022-10-18 remove buck converter schematic
    Moved to separate branch
2022-10-18 add pull ups, bypass caps for SD card
2022-10-22 update improved layout
2022-10-22 update production files
2022-10-22 update part
2022-10-22 update footprint
2022-10-22 update schematics PDF
2022-10-22 update part number for ESD
2022-10-22 fix VBUS trace
2022-10-24 fix two out of alignment traces
2022-10-29 update layout
2022-11-08 remove solder paste from ESP32 ground pad
2022-11-08 flip TX/RX pins for programmer port
2022-11-08 bump revision
2022-11-09 rename RX/TX to ESP_TX/ESP_RX
2022-11-15 fix issues found from first iteration production
2022-11-15 add buck converter schematic
